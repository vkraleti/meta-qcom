inherit devicetree

COMPATIBLE_MACHINE = "qcom-armv8"

SRC_URI = "\
    file://qcom-armv8-dummy.dts \
"
