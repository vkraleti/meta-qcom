require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:fb6214c45328265edbd8edca1262ec5b992d9984da40f3a51f5ea43874e07699"
