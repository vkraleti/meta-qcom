require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:a06d80aff03001573ecb74ddd3b6cf72b56b0fcbc465b412eddc3360aaf9b9b9"
