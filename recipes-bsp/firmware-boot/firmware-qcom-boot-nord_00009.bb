require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:d189ebf96afaaef2a1024e03c593f1821ee7855e21872d22311209315a6de39c"
