require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:90c14b5cbe7f174e0376ecad1fff1e9e2b8fbc2e3f2991b498c286b7e2d98f67"
