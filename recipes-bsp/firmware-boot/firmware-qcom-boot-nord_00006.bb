require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:bdfbae90f7d1724a3b97721b54f9fa9c6f703139853100a139fd501231ed7e3c"
