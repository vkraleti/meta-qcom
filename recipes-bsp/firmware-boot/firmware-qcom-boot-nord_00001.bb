require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "47ba0c1ada86e75cbb03309a1210fce224544298c95e620f6e69ae1bec4e9aba"
