require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "dae84461fcee7697a3372568b471a715678137ea8e978b99506b0e4b4ac1c699"
