require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:c33a87cd265556b8cf5c9a85cd2dcaf508fd05c35487709b8bc760c88c528c40"
