require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:3346f43ab8b3d230bc1a0c7df972c9e79ae4617c1aecfaa8022002ec47441e71"
