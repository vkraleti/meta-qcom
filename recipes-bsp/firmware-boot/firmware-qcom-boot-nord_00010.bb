require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:c38757a7e46bb69f6c11386078f9c86dbe698f3249faa924a18bcd0f0fafae63"
